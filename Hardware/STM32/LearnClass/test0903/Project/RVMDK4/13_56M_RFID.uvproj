# Keil uVision project 13_56M_RFID.uvproj, settings and files
target 13_56M_RFID (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 13_56M_RFID +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\FWlib\inc;..\..\User;..\..\Libraries\CMSIS;..\..\System\delay;..\..\System\sys;..\..\System\usart;..\..\Hardware\13_56M;..\..\Hardware\LED;..\..\Hardware\fn;..\..\Hardware\Relay;..\..\Hardware\Key;..\..\Hardware\lcdzm
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../../User/: stm32f10x_it.c main.c
  group FWlib
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Core
    ../../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group System
    ../../System/delay/: delay.c
    ../../System/sys/: sys.c
    ../../System/usart/: usart.c
  group Hardware
    ../../Hardware/13_56M/: 13_56M.c
    ../../Hardware/LED/: led.c
    ../../Hardware/fn/: fn.c
    ../../Hardware/Relay/: relay.c
    ../../Hardware/Key/: key.c
    ../../Hardware/lcdzm/: lcd.c
  group Startup
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
